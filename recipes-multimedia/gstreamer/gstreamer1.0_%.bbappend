# Add Gstreamer video plugin
RRECOMMENDS_${PN}_dragonboard-410c += "gstreamer1.0-plugins-v4l2"
